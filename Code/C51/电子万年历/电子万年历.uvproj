# Keil uVision project 电子万年历.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 电子万年历 +hex
  c flags: Optimize=8 SizeSpeed=1
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: main.c main.h
  group Hardware
    ./Hardware/: Delay.c Delay.h MatrixKey.c MatrixKey.h SPI.c SPI.h SPIOled.c SPIOled.h OLEDWord.h Timer1.c Timer1.h
